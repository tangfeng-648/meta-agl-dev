require ${@bb.utils.contains('AGL_FEATURES', 'agl-drm-lease', 'kmscube_agl-drm-lease.inc', '', d)}
