# Container Manager config for AGL Momi IVI demo on R-Car Gen3
FILESEXTRAPATHS:prepend := "${THISDIR}/cm-config-agl-momi-ivi-demo:"
