# Container Manager config for AGL flutter IVI demo on R-Car Gen3
FILESEXTRAPATHS:prepend := "${THISDIR}/cm-config-agl-flutter-ivi-demo:"
