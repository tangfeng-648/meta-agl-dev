# Container Manager config for AGL Qt IVI demo on R-Car Gen3
FILESEXTRAPATHS:prepend := "${THISDIR}/cm-config-agl-qt-ivi-demo:"
