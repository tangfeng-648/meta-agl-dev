# Container Manager config for AGL HTML5 IVI demo on R-Car Gen3
FILESEXTRAPATHS:prepend := "${THISDIR}/cm-config-agl-html5-ivi-demo:"
