do_install[network] = "1"
