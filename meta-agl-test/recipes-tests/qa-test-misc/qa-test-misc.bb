SUMMARY = "Qa Test Misc"
HOMEPAGE = "https://git.automotivelinux.org/src/qa-test-misc/"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=86d3f3a95c324c9479bd8986968f4327"

PN = 'qa-test-misc'
PV = '1'

SRC_URI = "git://gerrit.automotivelinux.org/gerrit/src/qa-test-misc;protocol=https;branch=master"
SRCREV = "761c64f22b8a6c1202a2c9caafda36e154e81d41"

S = "${WORKDIR}/git"
