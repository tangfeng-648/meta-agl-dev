IMAGE_INSTALL:append = " packagegroup-rvgpu"
